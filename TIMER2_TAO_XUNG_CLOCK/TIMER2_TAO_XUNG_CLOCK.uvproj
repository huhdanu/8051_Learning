# Keil uVision project TIMER2_TAO_XUNG_CLOCK.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: TIMER2_TAO_XUNG_CLOCK +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
