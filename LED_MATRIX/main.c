#include <regx52.h>
#include "..\Lib\delay.h"

#define LED_COL P2
#define LED_ROW P0

//khai bao mang so 0-9 LED matrix
unsigned char code count0_9[10][8] = {{0xFF,0xff,0x00,0x7E,0x7E,0x00,0xff,0xFF},
																			{0xFF,0xFF,0xDE,0xBE,0x00,0xFE,0xFE,0xFF},   
																			{0xFF,0xB1,0x76,0x76,0x76,0x8E,0xFF,0xFF},
																			{0xFF,0xFF,0x6E,0x6E,0x6E,0x6E,0x81,0xFF},  
																			{0xFF,0xF3,0xEB,0xDB,0xBB,0x00,0xFB,0xFF},
																			{0xFF,0xFF,0x0E,0x6E,0x6E,0x71,0xFF,0xFF},
																			{0xFF,0xFF,0x00,0x6E,0x6E,0x60,0xFF,0xFF},  
																			{0xFF,0xFF,0x1F,0x7F,0x7F,0x00,0xFF,0xFF},
																			{0xFF,0xFF,0x00,0x66,0x66,0x00,0xFF,0xFF},
																			{0xFF,0xFF,0x0E,0x6E,0x6E,0x00,0xFF,0xFF}}; 
void main()
{
	
	while(1)
	{
		unsigned char j,count;
		unsigned char i;
		
		
		for(count=0; count<10 ;count++)
		{
			for(i=0;i<100;i++)
			{
				for(j=0;j<8;j++)
				{
					LED_COL = count0_9[count][j];
					LED_ROW = 0x80>>j;  
					delay_ms(1);
					LED_ROW = 0x00;
				}
			}
		}
	}
}